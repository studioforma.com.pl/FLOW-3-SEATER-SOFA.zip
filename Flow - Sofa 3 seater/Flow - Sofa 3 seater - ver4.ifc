Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Flow - Sofa 3 seater - ver4.ifc
Time: 2025-11-11T15:11:35
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (12)
Name
 | Flow - Sofa 3 seater_0 - ObjectType: SketchupGroup
 | Flow - Sofa 3 seater_1 - ObjectType: SketchupGroup
 | Flow - Sofa 3 seater_2 - ObjectType: SketchupGroup
 | Flow - Sofa 3 seater_3 - ObjectType: SketchupGroup
 | Flow - Sofa 3 seater_4 - ObjectType: SketchupGroup
 | Flow - Sofa 3 seater_5 - ObjectType: SketchupGroup
 | Flow - Sofa 3 seater_6 - ObjectType: SketchupGroup
 | Flow - Sofa 3 seater_7 - ObjectType: SketchupGroup
 | Flow - Sofa 3 seater_8 - ObjectType: SketchupGroup
 | Flow - Sofa 3 seater_9 - ObjectType: SketchupGroup
 | Flow - Sofa 3 seater_10 - ObjectType: SketchupGroup
 | Flow - Sofa 3 seater_11 - ObjectType: SketchupGroup
